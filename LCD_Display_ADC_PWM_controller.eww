<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>E:\cufe_work\battery charger project\ide\tirex-content\msp\MSP430Ware_3_60_00_10\driverlib\examples\MSP430FR5xx_6xx\00_emptyProject\IAR\emptyProject.ewp</path>
  </project>
  <batchBuild/>
</workspace>


